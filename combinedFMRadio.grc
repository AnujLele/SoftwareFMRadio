options:
  parameters:
    generate_options: qt_gui
    id: combinedFMRadio
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: 50e3
  states: {}
- name: centerFrequency
  id: variable_qtgui_range
  parameters:
    start: 87e6
    step: 2e6
    stop: 200e6
    value: 162.55e6
  states: {}
- name: decimationFactor
  id: variable
  parameters:
    value: '4'
  states: {}
- name: minBandwidth
  id: variable_qtgui_range
  parameters:
    start: '20000'
    step: '10000'
    stop: '200000'
    value: '75000'
  states: {}
- name: playAudio
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    start: '-80'
    step: '5'
    stop: '0'
    value: '-40'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: samp_rate/decimationFactor
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern(str(centerFrequency))
    period: '20'
  states: {}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern(str(playAudio))
    period: '20'
  states: {}
- name: blocks_message_strobe_1
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '5'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, file_path = "/Users/anujlele/Documents/logFreq.txt", center_frequency = 96.9e6):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='EPB: Message to File',   # will show up in GRC
                  in_sig=None,
                  out_sig=None
              ) # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.message_port_register_in(pmt.intern('signalsDetected'))
              self.message_port_register_in(pmt.intern('centerFrequency'))
              self.set_msg_handler(pmt.intern('signalsDetected'), self.handle_message)
              self.set_msg_handler(pmt.intern('centerFrequency'), self.handle_message2)
              self.file_path = file_path
              self.centerFrequency = center_frequency
              
          def handle_message(self, msg):
              m = pmt.to_python(msg)
              message = str(m)
              signalIndex = message.rfind("array")
              while signalIndex != -1: # while "array" is found
                  detectedFreqOffset = ""
                  i = 7 # the index of the first digit we care about, singalIndex + "array[("
                  while message[signalIndex + i] != ',':
                      detectedFreqOffset += message[signalIndex + i]
                      i += 1
                  detectedFreq = int(float(detectedFreqOffset) + self.centerFrequency)
                  with open(self.file_path, 'a') as f:
                      f.write(str(detectedFreq) + "\n")
                  
                  message = message[:signalIndex]
                  signalIndex = message.rfind("array")

          def handle_message2(self, msg):
              self.centerFrequency = float(pmt.to_python(msg))
                  
          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0]
              return len(output_items[0])
    center_frequency: centerFrequency
    file_path: '"/Users/anujlele/Documents/logFreq.txt"'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, is_Passed = False):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.message_port_register_in(pmt.intern('Play_Audio?'))
              self.set_msg_handler(pmt.intern('Play_Audio?'), self.handle_message)
              self.isPassed = is_Passed

          def handle_message(self,msg):
              self.playAudio = pmt.to_python(msg)
              self.isPassed = (self.playAudio == "True")


          def work(self, input_items, output_items):
              if self.isPassed == True:
                  output_items[0][:] = input_items[0]
              else:
                  output_items[0][:] = 0
              return len(output_items[0])
    is_Passed: playAudio
  states: {}
- name: inspector_qtgui_sink_vf_0
  id: inspector_qtgui_sink_vf
  parameters:
    cfreq: '0'
    fft_len: '1024'
    manual: 'False'
    msgports: '1'
    rf_unit: '1'
    samp_rate: samp_rate
  states: {}
- name: inspector_signal_detector_cvf_0
  id: inspector_signal_detector_cvf
  parameters:
    auto: 'False'
    avg: '0.2'
    fft_len: '1024'
    logfile: log
    min_bw: '75000'
    quant: '0.0001'
    samp_rate: samp_rate
    sensitivity: '0.95'
    threshold: threshold
    window: window.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decimationFactor
    interp: '1'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate)
    interp: int(48e3 * 10 * decimationFactor)
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    bw0: bw
    comment: |-
      import sys
      sys.path.insert(0, "/Users/anujlele/radioconda/lib/python3.10/site-packages")
    freq0: centerFrequency
    gain0: '10'
    gain_mode0: 'True'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_message_strobe_0, strobe, epy_block_0, centerFrequency]
- [blocks_message_strobe_0_0, strobe, epy_block_0_0, 'Play_Audio?']
- [blocks_message_strobe_1, strobe, epy_block_0, signalsDetected]
- [blocks_multiply_const_vxx_0, '0', epy_block_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', inspector_signal_detector_cvf_0, '0']
- [epy_block_0_0, '0', audio_sink_0, '0']
- [epy_block_0_0, '0', audio_sink_0, '1']
- [inspector_qtgui_sink_vf_0, map_out, blocks_message_strobe_1, set_msg]
- [inspector_signal_detector_cvf_0, '0', inspector_qtgui_sink_vf_0, '0']
- [inspector_signal_detector_cvf_0, map_out, inspector_qtgui_sink_vf_0, map_in]
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [rtlsdr_source_0, '0', blocks_multiply_const_vxx_1, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
